## boards/raytac/mdbt50q_db_atms/board.yml
```yaml
board:
  name: raytac_mdbt50q_db_atms
  vendor: raytac
  socs:
  - name: nrf52833
```
